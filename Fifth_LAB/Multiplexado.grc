options:
  parameters:
    author: Peña_Hernandez
    copyright: Peña_Hernandez
    generate_options: qt_gui
    id: Multiplexado
    output_language: python
    title: Multiplexado
  states: {}

blocks:
- name: Delay_1
  id: variable_qtgui_range
  parameters:
    label: Delay_1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: Delay_2
  id: variable_qtgui_range
  parameters:
    label: Delay_2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Delay_3
  id: variable_qtgui_range
  parameters:
    label: Delay_3
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Senal Cuadrada
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '50000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de Pulso
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: ModuladorPAM_1
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: samp_rate
    w: w
  states: {}
- name: ModuladorPAM_1_0
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: samp_rate
    w: w
  states: {}
- name: ModuladorPAM_1_1
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: samp_rate
    w: w
  states: {}
- name: ModuladorPAM_1_2
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: samp_rate
    w: w
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Delay_1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Delay_2
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Delay_3
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Add all signals
  states: {}

connections:
- [ModuladorPAM_1, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_1, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_1_0, '0', blocks_delay_0, '0']
- [ModuladorPAM_1_1, '0', blocks_delay_0_0, '0']
- [ModuladorPAM_1_2, '0', blocks_delay_0_1, '0']
- [analog_sig_source_x_0_0, '0', ModuladorPAM_1, '0']
- [analog_sig_source_x_0_0_0, '0', ModuladorPAM_1_0, '0']
- [analog_sig_source_x_0_0_1, '0', ModuladorPAM_1_1, '0']
- [analog_sig_source_x_0_0_2, '0', ModuladorPAM_1_2, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
