options:
  parameters:
    author: Peña_Hernandez
    copyright: Grupo_J1A_G02
    description: 'Modulacion PM '
    generate_options: qt_gui
    id: ModulacionPMJ1AG03
    output_language: python
    title: Modulacion PM J1A G02
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '30'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    orient: Qt.Horizontal
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: Calculopotencia_J1A3_0
  id: Calculopotencia_J1A3
  parameters:
    I_vect: '1024'
  states: {}
- name: EnvolventeComplejaPMJ1A_0
  id: EnvolventeComplejaPMJ1A
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventeComplejaPMJ1A_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventeComplejaPMJ1A_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPMJ1A_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPMJ1A_0, '0']
- [blocks_complex_to_mag_0, '0', Calculopotencia_J1A3_0, '0']

metadata:
  file_format: 1
